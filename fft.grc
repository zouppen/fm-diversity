<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fft_with_filter</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Zero padding FFT</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>2*samp_rate</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>blocks_vector_insert_x_0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>period</key><value>2*samp_rate</value></param>
<param><key>vector</key><value>np.zeros(samp_rate)</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2*samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>comment</key><value>Low pass filter (in units of blocksize)</value></param>
<param><key>label</key><value>High pass cutoff</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>fft_highpass</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
from pprint import pprint

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """High pass filter for FFT output"""

    def __init__(self, vector_length=2, cutoff=0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        self.vector_length = vector_length
        self.cutoff = cutoff

        gr.sync_block.__init__(
            self,
            name='High pass filter for FFT vector',   # will show up in GRC
            in_sig  = [(np.complex64, vector_length)],
            out_sig = [(np.complex64, vector_length)]
        )

    def work(self, input_items, output_items):
        """Actually, just zero fill start and end of the vector"""
        
        output_items[0][:] = input_items[0]
        
        for i in range(1,self.cutoff):
            output_items[0][0,i-1] = 0
            output_items[0][0,-i] = 0

        return len(output_items[0])
</value></param>
<param><key>cutoff</key><value>cutoff</value></param>
<param><key>vector_length</key><value>2*samp_rate</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>2*samp_rate</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(2*samp_rate)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>blocksize</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_insert_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_highpass</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>fft_highpass</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_vector_insert_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
