<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mpx_client</value></param>
<param><key>author</key><value>Zouppen</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Broadcast FM MPX recevier</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1e6*frequency</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_trans</value></param>
<param><key>value</key><value>2e4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_in_packet</value></param>
<param><key>value</key><value>(mtu-28-8-8-32)/4*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>upsample</value></param>
<param><key>value</key><value>900001/mpx_rate+1</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>2**15</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>scale</key><value>1000</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deviation</value></param>
<param><key>label</key><value>deviation (Hz)</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>80e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>RTL device string</value></param>
<param><key>short_id</key><value>D</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl=0</value></param>
</block>
<block>
<key>fm_snr</key>
<param><key>id</key><value>fm_snr_0</value></param>
<param><key>deviation</key><value>deviation</value></param>
<param><key>filter_trans</key><value>2e4</value></param>
<param><key>decimator</key><value>upsample</value></param>
<param><key>noise_high</key><value>noise_high</value></param>
<param><key>noise_low</key><value>noise_low</value></param>
<param><key>samp_rate</key><value>mpx_rate*upsample</value></param>
<param><key>signal_freq</key><value>-offtune</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>signal frequency in MHz</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF gain (dB)</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host</value></param>
<param><key>label</key><value>Hostname</value></param>
<param><key>short_id</key><value>H</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>localhost</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>key</value></param>
<param><key>label</key><value>HMAC key</value></param>
<param><key>short_id</key><value>k</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>kissa13</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mpx_rate</value></param>
<param><key>label</key><value>sample rate of MPX</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mtu</value></param>
<param><key>label</key><value>Network MTU (bytes)</value></param>
<param><key>short_id</key><value>m</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_high</value></param>
<param><key>label</key><value>noise high frequency, relative to signal (Hz)</value></param>
<param><key>short_id</key><value>u</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>240e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_low</value></param>
<param><key>label</key><value>noise low frequency, relative to signal (Hz)</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>140e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offtune</value></param>
<param><key>label</key><value>tuner offset to avoid LO peak (Hz)</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>120000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>UDP port</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>15400</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq+offtune</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>device</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>mpx_rate*upsample</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>udp_sender</value></param>
<param><key>_source_code</key><value># -*- coding: utf-8 -*-
"""
UDP sink with HMAC

Sends UDP data with timestamp, packet counter, and HMAC
"""

import numpy as np
from gnuradio import gr
from array import array
import time
import struct
import hmac
import hashlib
import socket
import sys

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, host='localhost', port=51400, hmac_key='kissa', items_per_packet=100):
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='UDP sender with HMAC',   # will show up in GRC
            in_sig=[np.int16],
            out_sig=[]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.hmac_key = hmac_key
        self.items_per_packet = items_per_packet

        # Other variables
        self.count = 0
        self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
        self.sock.connect((host, port))
        self.little = sys.byteorder == 'little'
        self.start_time = time.time()*1e6

    def work(self, input_items, output_items):
        """Wait until given number of items are ready, then send UDP packet with HMAC"""
        if len(input_items[0]) &lt; self.items_per_packet: return 0

        # Header contains startup time in µs and sample counter
        header = struct.pack('&gt;QQ', self.start_time, self.count)

        # Payload is big-endian array of samples
        arr = input_items[0][:self.items_per_packet]
        if self.little:
            arr = arr.byteswap()
        content = arr.tostring()

        # Packet ends with SHA256 HMAC
        hasher = hmac.new(self.hmac_key, header, digestmod=hashlib.sha256)
        hasher.update(content)
        hash = hasher.digest()

        try:
            self.sock.send(header + content + hash)
        except socket.error:
            print("UDP port is probably closed")
        
        self.count += self.items_per_packet
        return self.items_per_packet
</value></param>
<param><key>hmac_key</key><value>key</value></param>
<param><key>host</key><value>host</value></param>
<param><key>items_per_packet</key><value>samp_in_packet</value></param>
<param><key>port</key><value>port</value></param>
</block>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>udp_sender</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_snr_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_snr_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>4</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fm_snr_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source</source_block_id><sink_block_id>fm_snr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
