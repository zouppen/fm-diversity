<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mpx_client</value></param>
<param><key>author</key><value>Zouppen</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Broadcast FM MPX recevier</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha_noise</value></param>
<param><key>value</key><value>0.00001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1e6*frequency</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_trans</value></param>
<param><key>value</key><value>2e4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>upsample</value></param>
<param><key>value</key><value>900001/mpx_rate+1</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>(mpx_rate*upsample)/(3.14159*2*deviation)</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-(mpx_rate*upsample)/(3.14159*offtune)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>2**15</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>scale</key><value>1000</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>-math.log10(noise_high-noise_low)</value></param>
<param><key>n</key><value>2</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_1</value></param>
<param><key>k</key><value>-math.log10(deviation)</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_1</value></param>
<param><key>alpha</key><value>alpha_noise</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>host</value></param>
<param><key>port</key><value>port</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deviation</value></param>
<param><key>label</key><value>deviation (Hz)</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>80e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>signal frequency in MHz</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF gain (dB)</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host</value></param>
<param><key>label</key><value>host name</value></param>
<param><key>short_id</key><value>H</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>localhost</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>80e3</value></param>
<param><key>decim</key><value>upsample</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>mpx_rate*upsample</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mpx_rate</value></param>
<param><key>label</key><value>sample rate of MPX</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>mpx_sink</value></param>
<param><key>stream_id</key><value>mpx</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>noise_filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-offtune+noise_high</value></param>
<param><key>low_cutoff_freq</key><value>-offtune+noise_low</value></param>
<param><key>samp_rate</key><value>mpx_rate*upsample</value></param>
<param><key>width</key><value>filter_trans/deviation/2*(noise_high-noise_low)</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_high</value></param>
<param><key>label</key><value>noise high frequency, relative to signal (Hz)</value></param>
<param><key>short_id</key><value>u</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>240e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_low</value></param>
<param><key>label</key><value>noise low frequency, relative to signal (Hz)</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>140e3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>noise_sink</value></param>
<param><key>stream_id</key><value>noise</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>noise_source</value></param>
<param><key>stream_id</key><value>noise</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offtune</value></param>
<param><key>label</key><value>tuner offset to avoid LO peak (Hz)</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>120000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>UDP port</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>51400</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>mpx_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>MPX output</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Signal</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Noise</value></param>
<param><key>name</key><value>Signal and noise</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>mpx_rate*upsample</value></param>
<param><key>type</key><value>float</value></param>
<param><key>yunit</key><value>Bel</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-15</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>mpx_rate*upsample</value></param>
<param><key>fc</key><value>center_freq+offtune</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>5,0,4,2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>name</key><value>Baseband</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>upsample</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq+offtune</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>mpx_rate*upsample</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>signal_filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-offtune+deviation</value></param>
<param><key>low_cutoff_freq</key><value>-offtune-deviation</value></param>
<param><key>samp_rate</key><value>mpx_rate*upsample</value></param>
<param><key>width</key><value>filter_trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>signal_sink</value></param>
<param><key>stream_id</key><value>signal</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>signal_source_for_demod</value></param>
<param><key>stream_id</key><value>signal</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>signal_source_for_mag</value></param>
<param><key>stream_id</key><value>signal</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>snr_sink</value></param>
<param><key>stream_id</key><value>snr</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>mpx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>mpx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>snr</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>noise</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>signal</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_nlog10_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_1</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>mpx_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noise_filter</source_block_id><sink_block_id>noise_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noise_source</source_block_id><sink_block_id>blocks_rms_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>snr_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source</source_block_id><sink_block_id>noise_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source</source_block_id><sink_block_id>signal_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_filter</source_block_id><sink_block_id>signal_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_source_for_demod</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_source_for_mag</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
