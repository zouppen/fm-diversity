<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_snr</value></param>
<param><key>author</key><value>Joel Lehtonen</value></param>
<param><key>description</key><value>Demodulates FM and outputs decoded audio and signal-to-noise ratio</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>FM demodulator with SNR</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha_noise</value></param>
<param><key>value</key><value>0.00001</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>baseband_source</value></param>
<param><key>label</key><value>baseband</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-float(signal_freq)/deviation</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decimator</value></param>
<param><key>label</key><value>MPX signal decimator</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deviation</value></param>
<param><key>label</key><value>Deviation</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>80e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filter_trans</value></param>
<param><key>label</key><value>Filter transition width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2e4</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>fm_demod</value></param>
<param><key>gain</key><value>samp_rate/(3.14159*2*deviation)</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>fm_low_pass</value></param>
<param><key>cutoff_freq</key><value>float(samp_rate)/decimator*0.40</value></param>
<param><key>decim</key><value>decimator</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>noise_downsampler</value></param>
<param><key>decim</key><value>decimator</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>noise_filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>signal_freq+noise_high</value></param>
<param><key>low_cutoff_freq</key><value>signal_freq+noise_low</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>filter_trans/deviation/2*(noise_high-noise_low)</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_high</value></param>
<param><key>label</key><value>Noise high frequency, relative to signal</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>240e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_low</value></param>
<param><key>label</key><value>Noise low frequency, relative to signal</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>140e3</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>noise_rms</value></param>
<param><key>alpha</key><value>alpha_noise</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>noise_to_belhz</value></param>
<param><key>k</key><value>-math.log10(noise_high-noise_low)</value></param>
<param><key>n</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>signal_downsampler</value></param>
<param><key>decim</key><value>decimator</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>signal_filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>signal_freq+deviation</value></param>
<param><key>low_cutoff_freq</key><value>signal_freq-deviation</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>filter_trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>signal_freq</value></param>
<param><key>label</key><value>Signal center frequency</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>-120000</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>signal_to_belhz</value></param>
<param><key>k</key><value>-math.log10(deviation)</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>signal_to_mag</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sink0_bb_signal</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>bb_signal</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sink1_bb_noise</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>bb_noise</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sink2_mpx</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>mpx</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sink3_signal</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>signal</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sink4_noise</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>noise</value></param>
</block>
<connection><source_block_id>baseband_source</source_block_id><sink_block_id>noise_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>baseband_source</source_block_id><sink_block_id>signal_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>sink2_mpx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_demod</source_block_id><sink_block_id>fm_low_pass</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_low_pass</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noise_downsampler</source_block_id><sink_block_id>noise_to_belhz</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noise_filter</source_block_id><sink_block_id>noise_rms</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noise_filter</source_block_id><sink_block_id>sink1_bb_noise</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noise_rms</source_block_id><sink_block_id>noise_downsampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noise_to_belhz</source_block_id><sink_block_id>sink4_noise</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_downsampler</source_block_id><sink_block_id>signal_to_belhz</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_filter</source_block_id><sink_block_id>fm_demod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_filter</source_block_id><sink_block_id>signal_to_mag</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_filter</source_block_id><sink_block_id>sink0_bb_signal</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_to_belhz</source_block_id><sink_block_id>sink3_signal</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_to_mag</source_block_id><sink_block_id>signal_downsampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
